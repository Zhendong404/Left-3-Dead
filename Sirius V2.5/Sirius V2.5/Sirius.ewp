# IAR project Sirius.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TWR_K60N512
  ICCARM.CCIncludePath2: src\Sources\H; src\Sources\H\Component_H; src\Sources\H\Frame_H; src\Sources\H\Function_H; src\Sources\H\SD_H
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Sirius.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: src\Project_Settings\Link\Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  ILINK.IlinkIcfFile: src\Project_Settings\Link\Pflash.icf
  group Project_Settings/link
    src/Project_Settings/Link/: Pflash.icf Ram.icf
  group Project_Settings/Startup_Code
    src/Project_Settings/Startup_Code/: crt0.s start.c
  group Sources
    src/: SiriusLog.txt
  group Sources/C
    src/Sources/C/: isr.c main.c
  group Sources/C/Component_C
    src/Sources/C/Component_C/: DMA.c gpio.c light.c Pit.c uart.c wdog.c
  group Sources/C/Frame_C
    src/Sources/C/Frame_C/: common.c sysinit.c vectors.c
  group Sources/C/Function_C
    src/Sources/C/Function_C/: CameraSet.c Ftm.c ImageGet.c ImagePro.c RunControl.c SCCB.c VirtualScope.c
  group Sources/H
    src/Sources/H/: includes.h
  group Sources/H/Component_H
    src/Sources/H/Component_H/: DMA.h gpio.h light.h Pit.h uart.h wdog.h
  group Sources/H/Frame_H
    src/Sources/H/Frame_H/: common.h MK60N512VMD100.h sysinit.h vectors.h
  group Sources/H/Function_H
    src/Sources/H/Function_H/: CameraSet.h Ftm.h ImageGet.h ImagePro.h RunControl.h SCCB.h VirtualScope.h
